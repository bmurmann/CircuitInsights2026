.param ibn = 1.05e-04
.param W0 = 3.85e-05
.param W1 = 1.92e-05
.param W2 = 6.65e-05
.param L0 = 5.00e-07
.param L1 = 5.00e-07
.param L2 = 5.00e-07
.param nf0 = 8.0
.param nf1 = 4.0
.param nf2 = 14.0
